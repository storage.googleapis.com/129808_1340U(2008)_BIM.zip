Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-15T14:00:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 15 14:00:27 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{17B14A96-DF29-4E1A-AAB0-DE08D23DDDDF}\ifc * Database version: 5507 * Database creation date: Fri Mar 15 14:00:27 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 15 14:00:27 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 15 14:00:27 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1340U Bath and shower faucet, 1340U(2008):1340U Bath and shower faucet:352625
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalWidth: 282 mm; Projection: 180 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1340U(2008); ConvergoRefNr: 0087-1803-0016-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 12/03/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150073267; EN Standard: EN 1111; Noise Class: I (ISO 3822) Oras lab.
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1340U; Catalog Drawing URL: http://static.oras.com/catdrw/1340U; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/1340U; FDV Document URL: http://www.oras.com/datasheet/1340U/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1340U; Group: Bath and shower faucets; Long Marketing: Thermostatic bath and shower faucet that reacts quickly and precisely to the changes of incoming water temperature and keeps the water temperature as selected. Temperature limiter in the handle. Spout with diverter and aerator. EcoFlow control. Includes eccentric unions and cover plates. Non-return valves and litter filters are included.; Manufacturer: Oras; Model: 1340U Bath and shower faucet; Name_en: 1340U Bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 370 x 192 x 90; Package Weight: 2.89 kg; Product Code: 1340U; Product Datasheet: http://www.oras.com/datasheet/1340U/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1340U; Product URL: http://static.oras.com/1340U; Type Name: 1340U Bath and shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection: Covered eccentric unions; Diverter: Push diverter; Eco Flow At 300kPa: 0.00565035 m3/s; Flow: EcoFlow control; Flow Rate At 300kPa: 0.0116538 m3/s; Installation and Maintenance: http://static.oras.com/manual/1340U; Installation Type: Wall-mounted; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Litter filter(s);Non-return valve(s); Spare Parts: http://static.oras.com/sp/1340U; Spout Type: Fixed spout; Temperature: Temperature limiter;Temperature fixable
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1340U(2008); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1340U; Name: 1340U Bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 282x203x78 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1340U; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1340U Bath and shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.096844 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00444866 m3
Identity Data - Mark: 24
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1340U(2008): 1340U Bath and shower faucet; Family and Type: 1340U(2008): 1340U Bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1340U(2008): 1340U Bath and shower faucet; Type Id: 1340U(2008): 1340U Bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
